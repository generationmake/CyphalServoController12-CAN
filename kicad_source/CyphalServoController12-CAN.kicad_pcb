# Repository generationmake/CyphalServoController12-CAN

File README.md:

# CyphalServoController12/CAN
Board to control up to 12 servos with a Raspberry Pi Pico to connect via CAN using OpenCyphal and UCANPHY Micro

## Description

### analog measurements

| **channel** | **usage**       | **range**  |
|:-----------:|:---------------:|:----------:|
| ADC0        | battery voltage | 0 - 66 V   |
| ADC1        | servo voltage   | 0 - 6.6 V  |
| ADC2        | CAN bus voltage | 0 - 6.6 V  |

### power supply

The power for the microcontroller and the CAN interface can be fed via the CAN connector or thepower regulator for the servos. The power regulator for the servos can be enabled and disabled by the microcontroller to save power in stand-by.

input voltage: 10 - 40 V

## PCB

### Top

### Bottom

## KiCad design kicad_source/CyphalServoController12-CAN.kicad_pcb

Parts:
C1, C2, C3, C4: 100nF; C_0603_1608Metric
CN1, CN8: SM04B-SRSS-TB; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
CN2, CN3, CN4, CN5, CN6, CN7: CONN_02X03; PinHeader_2x03_P2.54mm_Horizontal
CN9: RASPBERRYPI_PICO; RASPI_PICO_SOLDER_Kopie
D1: LED red; LED_0603_1608Metric
D2: LED yellow; LED_0603_1608Metric
L1: Label; generationmake_small_silk
L2: Label; generationmake_small_solder
L3: Label; opencyphal_small
MECH1, MECH2, MECH3, MECH4: MHP_3.2_5.8
R1, R2, R3, R4, R5, R6, R9, R10, R11, R12, R13, R14, R34, R35: 100R; R_0603_1608Metric
R7, R8, R18: 10k; R_0603_1608Metric
R15, R16, R20, R21: 100k; R_0603_1608Metric
R17: 190k; R_0603_1608Metric
R19, R22: 3k3; R_0603_1608Metric
SW1: SPST; SW_SPST_CK_RS282G05A3
U1: 24LC64; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: C1.1, CN1.2, CN8.2, CN9.36 (3V3(OUT)), R7.1, R8.1, U1.8 (VCC); also elsewhere on the board
+5V: CN9.39 (VSYS); also elsewhere on the board
+BATT: R17.1; also elsewhere on the board
/I2C_SCL: CN1.4, CN9.7 (GP5/SPI0_CS/I2C0_SCL/UART1_RX), R7.2, U1.6 (SCL)
/I2C_SDA: CN1.3, CN9.6 (GP4/SPI0_RX/I2C0_SDA/UART1_TX), R8.2, U1.5 (SDA)
/LED2: CN9.27 (GP21/I2C0_SCL), R19.1
/LED2_R: D1.2 (A), R19.2
/LED3: CN9.29 (GP22), R22.1
/LED3_R: D2.2 (A), R22.2
/MEAS_5V: C4.1, CN9.32 (GP27/ADC1/I2C1_SCL), R20.2, R21.1
/MEAS_BATT: C3.1, CN9.31 (GP26/ADC0/I2C1_SDA), R17.2, R18.1
/MEAS_CANVCC: C2.1, CN9.34 (GP28/ADC2), R15.2, R16.1
/MP1: CN1.MP (MountPin)
/MP2: CN8.MP (MountPin)
/RESET: CN9.30 (RUN), SW1.1
/SERVO00: CN9.4 (GP2/SPI0_SCK/I2C1_SDA), R9.2
/SERVO00_R: CN2.2, R9.1
/SERVO01: CN9.5 (GP3/SPI0_TX/I2C1_SCL), R1.1
/SERVO01_R: CN2.1, R1.2
/SERVO02: CN9.9 (GP6/SPI0_SCK/I2C1_SDA), R10.2
/SERVO02_R: CN3.2, R10.1
/SERVO03: CN9.10 (GP7/SPI0_TX/I2C1_SCL), R2.1
/SERVO03_R: CN3.1, R2.2
/SERVO04: CN9.11 (GP8/SPI1_RX/I2C0_SDA/UART1_TX), R11.2
/SERVO04_R: CN4.2, R11.1
/SERVO05: CN9.12 (GP9/SPI1_CS/I2C0_SCL/UART1_RX), R3.1
/SERVO05_R: CN4.1, R3.2
/SERVO06: CN9.14 (GP10/SPI1_SCK/I2C1_SDA), R12.2
/SERVO06_R: CN5.2, R12.1
/SERVO07: CN9.15 (GP11/SPI1_TX/I2C1_SCL), R4.1
/SERVO07_R: CN5.1, R4.2
/SERVO08: CN9.16 (GP12/SPI1_RX/I2C0_SDA/UART0_TX), R13.2
/SERVO08_R: CN6.2, R13.1
/SERVO09: CN9.17 (GP13/SPI1_CS/I2C0_SCL/UART0_RX), R5.1
/SERVO09_R: CN6.1, R5.2
/SERVO10: CN9.19 (GP14/SPI1_SCK/I2C1_SDA), R14.2
/SERVO10_R: CN7.2, R14.1
/SERVO11: CN9.20 (GP15/SPI1_TX/I2C1_SCL), R6.1
/SERVO11_R: CN7.1, R6.2
/SER_RX: CN8.4, R34.2
/SER_TX: CN8.3, R35.2
CANVCC: R15.1; also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, CN1.1, CN2.5, CN2.6, CN3.5, CN3.6, CN4.5, CN4.6, CN5.5, CN5.6, CN6.5, CN6.6, CN7.5, CN7.6, CN8.1, CN9.3 (GND), CN9.8 (GND), CN9.13 (GND), CN9.18 (GND), CN9.23 (GND), CN9.28 (GND), CN9.33 (GND/AGND), CN9.38 (GND), D1.1 (K), D2.1 (K), R16.2, R18.2, R21.2, SW1.2, U1.1 (A0), U1.2 (A1), U1.3 (A2), U1.4 (VSS), U1.7 (WP); also elsewhere on the board
MCP2515_CS: CN9.22 (GP17/SPI0_CS/I2C0_SCL/UART0_RX); also elsewhere on the board
MCP2515_INT: CN9.26 (GP20/I2C0_SDA); also elsewhere on the board
MISO: CN9.21 (GP16/SPI0_RX/I2C0_SDA/UART0_TX); also elsewhere on the board
MOSI: CN9.25 (GP19/SPI0_TX/I2C1_SCL); also elsewhere on the board
SCK: CN9.24 (GP18/SPI0_SCK/I2C1_SDA); also elsewhere on the board
VCC: CN2.3, CN2.4, CN3.3, CN3.4, CN4.3, CN4.4, CN5.3, CN5.4, CN6.3, CN6.4, CN7.3, CN7.4, R20.1; also elsewhere on the board
VCC_EN: CN9.1 (GP0/SPI0_RX/I2C0_SDA/UART0_TX), R35.1; also elsewhere on the board
VCC_PG: CN9.2 (GP1/SPI0_CS/I2C0_SCL/UART0_RX), R34.1; also elsewhere on the board

Notes on the sheet:
serial connector
qwiic connector
mounting holes
I2C address: 0x50
I2C Eeprom to store settings

Parts:
C5, C8: 100nF; C_0603_1608Metric
C6, C7: 10pF; C_0603_1608Metric
CN10, CN11: GH_SM04B-GHS-TB; JST_GH_SM04B-GHS-TB_1x04-1MP_P1.25mm_Horizontal
D3: MBR0530T1G; D_SOD-123
F1: nanoSMDC050F; Fuse_1206_3216Metric
R23, R24, R25: 10k; R_0603_1608Metric
U2: MCP2515; SOIC-18W_7.5x11.6mm_P1.27mm
U3: SN65HVD232; SOIC-8_3.9x4.9mm_P1.27mm
Y1: 16MHz; Crystal_SMD_3.2x2.5mm_4Pad

Connections:
+3V3: C5.1, C8.1, R23.1, R24.1, R25.1, U2.18 (VDD), U3.3 (VCC); also elsewhere on the board
+5V: F1.1; also elsewhere on the board
/MCP2515/CANH: CN10.2, CN11.2, U3.7 (CANH)
/MCP2515/CANL: CN10.3, CN11.3, U3.6 (CANL)
/MCP2515/MCP2515_OSC1: C7.1, U2.8 (OSC1), Y1.3
/MCP2515/MCP2515_OSC2: C6.1, U2.7 (OSC2), Y1.1
/MCP2515/MCP2515_RESET: R25.2, U2.17 (RESET#)
/MCP2515/MCP2515_RX0BUF: U2.11 (RX0BUF#)
/MCP2515/MCP2515_RX1BUF: U2.10 (RX1BUF#)
/MCP2515/MCP2515_SOF: U2.3 (CLKOUT/SOF)
/MCP2515/MCP2515_TX0RTS: U2.4 (TX0RTS#)
/MCP2515/MCP2515_TX1RTS: U2.5 (TX1RTS#)
/MCP2515/MCP2515_TX2RTS: U2.6 (TX2RTS#)
/MCP2515/MP3: CN10.MP (MountPin), CN11.MP (MountPin)
/MCP2515/RXCAN: U2.2 (RXCAN), U3.4 (R)
/MCP2515/TXCAN: U2.1 (TXCAN), U3.1 (D)
CANVCC: CN10.1, CN11.1, D3.2 (A); also elsewhere on the board
GND: C5.2, C6.2, C7.2, C8.2, CN10.4, CN11.4, U2.9 (VSS), U3.2 (GND), U3.8 (NC1), Y1.2 (case), Y1.4 (case); also elsewhere on the board
MCP2515_CS: R24.2, U2.16 (CS#); also elsewhere on the board
MCP2515_INT: R23.2, U2.12 (INT); also elsewhere on the board
MISO: U2.15 (SO); also elsewhere on the board
MOSI: U2.14 (SI); also elsewhere on the board
unnamed: D3.1 (K), F1.2
SCK: U2.13 (SCK); also elsewhere on the board

Notes on the sheet:
connect pin to GND to allow usage of SN65HVD230
UCANPHY Micro connectors
30V 500mA
CAN in
CAN out

Parts:
C9: 10nF; C_0603_1608Metric
C10, C16: 4.7uF 50V; C_1210_3225Metric
C11: 1 uF; C_0603_1608Metric
C12: 2.2 uF; C_0603_1608Metric
C13, C15: 100 uF / 50 V; CP_Elec_8x10
C14, C17: 100 nF; C_0603_1608Metric
C18, C21: 1000 uF / 10 V; CP_Elec_8x10
C19, C20, C22, C23, C24: 47uF 10V; C_1210_3225Metric
CN12: Powerpole_2; POWERPOLE_hor_2
CN13: DNI; PhoenixContact_MC_1,5_2-G-3.5_1x02_P3.50mm_Horizontal
CN14: DNI; PinHeader_1x02_P2.54mm_Vertical
D4: SMCJ40A; D_SMC
D5: LED green; LED_0603_1608Metric
D6: MBR0530T1G; D_SOD-123
L4: 7443251000 (10 uH); L_Wuerth_HCI-1050
R26, R31: 120k; R_0603_1608Metric
R27, R32: 20k; R_0603_1608Metric
R28: 10k; R_0603_1608Metric
R29: 1R; R_0603_1608Metric
R30: 30k; R_0603_1608Metric
R33: 2k2; R_0603_1608Metric
U4: RAA211650; QFN-28-1EP_4x5mm_P0.5mm_EP2.65x3.65mm

Connections:
+5V: D6.1 (K); also elsewhere on the board
+BATT: C10.1, C13.1, C15.1, C16.1, CN12.1, CN13.1, D4.1 (A1), R31.1, U4.3 (PVIN), U4.4 (PVIN), U4.18 (PVIN), U4.19 (PVIN); also elsewhere on the board
/Power/AVCC: C11.2, R28.1, R29.2, U4.6 (MODE/SYNC), U4.7 (RT), U4.10 (COMP), U4.12 (V3_DLY), U4.15 (AVCC)
/Power/BOOT: C14.1, U4.22 (BOOT)
/Power/FB: R26.2, R27.1, U4.11 (FB)
/Power/PHASE: C14.2, L4.1, U4.23 (PHASE), U4.24 (PHASE), U4.25 (PHASE), U4.26 (PHASE), U4.27 (PHASE)
/Power/PVCC: C12.2, R29.1, U4.17 (PVCC)
/Power/SET: R30.1, U4.8 (SET)
/Power/SS: C9.2, U4.9 (SS)
GND: C9.1, C10.2, C11.1, C12.1, C13.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, CN12.2, CN13.2, CN14.2, D4.2 (A2), D5.1 (K), R27.2, R30.2, R32.2, U4.1 (PGND), U4.2 (PGND), U4.14 (AGND), U4.20 (PGND), U4.21 (PGND), U4.28 (PGND), U4.29 (EPAD); also elsewhere on the board
unnamed: D5.2 (A), R33.2
VCC: C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, CN14.1, D6.2 (A), L4.2, R26.1, R33.1, U4.16 (EBIAS); also elsewhere on the board
VCC_EN: R31.2, R32.1, U4.5 (EN); also elsewhere on the board
VCC_PG: R28.2, U4.13 (PG); also elsewhere on the board

Notes on the sheet:
Wuerth 7443251000
EN set to 10.5 V
+BATT max 40 V
ECC ZR100102MHA EMZR100ARA102MHA0G
set to internal compensation
ECC ZA500101MHA
RT to AVCC sets the frequency to 500 kHz
30V 500mA
VCC set to 5.6 V
Powerpole connector
SS set to 10 ms

Board: 2 copper layers, 81.0 x 57.0 mm, 94 parts (1 on the bottom side), 66 nets.

## Commit log

2023-03-26 updated some labels
2023-05-01 generated step file
2023-05-01 added freecad project
2023-05-01 generated stl files for production
2023-09-23 renamed files
2023-09-23 renamed readme
2023-09-23 renamed comments and labels in kicad project
